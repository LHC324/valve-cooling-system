# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __STDC_LIMIT_MACROS, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;applications;applications\lhc_modbus\Inc;applications\lhc_dwin\Inc;board\CubeMX_Config\Inc;.;packages\CmBacktrace-v1.4.1;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\finsh;packages\FlashDB-v1.1.2\inc;.;rt-thread\include;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x3d000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/lhc_dwin/Src/: dwin.c dwin_port.c tool.c
    applications/lhc_modbus/Src/: small_modbus.c small_modbus_port.c
    applications/: main.c flash.c measure.c stm32_irq.c io_signal.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/pm/: lptimer.c pm.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: main.c stm32f1xx_hal_msp.c
    board/: board.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group FlashDB
    packages/FlashDB-v1.1.2/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c fdb_cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_cec.c stm32f1xx_hal.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
